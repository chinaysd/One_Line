# Keil uVision project One_Line.uvproj, settings and files
target One_Line (MCS-51)
  device: SC92F7321 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: One_Line +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\lib;..\user
  group Startup
    ./: STARTUP.A51
  group User
    ../user/: main.c system.c
  group Bsp
    ../bsp/: bsp_led.c bsp_oneline.c bsp_timer.c TimeOut.c
